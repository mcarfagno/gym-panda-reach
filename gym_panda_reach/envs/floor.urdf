Commit message: added debug lines in env

File: gym_panda_reach/envs/floor.urdf (robot description, URDF)
Before this commit: robot floor, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=4 3 0.01; visual box size=4 3 0.01
